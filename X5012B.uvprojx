# Keil uVision project X5012B.uvprojx, settings and files
target X5012B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: X5012B +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -DNDEBUG
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./freeRTOS;./freeRTOS/include;./freeRTOS/portable;./Application;./Common;./Driver;./Interface;./Interface/ETH;./Interface/ETH/DHCP;./Interface/ETH/DNS;./Interface/ETH/httpServer;./Interface/ETH/W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group freeRTOS/include
    ./freeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freeRTOS/portable
    ./freeRTOS/portable/: heap_4.c port.c portmacro.h
  group freeRTOS
    ./freeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group ETH/DHCP
    ./Interface/ETH/DHCP/: dhcp.c dhcp.h
  group ETH/DNS
    ./Interface/ETH/DNS/: dns.c dns.h
  group ETH/httpServer
    ./Interface/ETH/httpServer/: httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h
  group ETH/W5500
    ./Interface/ETH/W5500/: w5500.c w5500.h
  group interface/ETH
    ./Interface/ETH/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application
    ./Application/: App_FreeRTOS.c App_FreeRTOS.h App_Network.c App_Network.h App_Commu.c App_Commu.h
  group Interface
    ./Interface/: Int_EEPROM.c Int_EEPROM.h
  group Driver
    ./Driver/: Dri_I2C.c Dri_I2C.h Dri_CS5530.c Dri_CS5530.h
  group Common
    ./Common/: Com_Debug.c Com_Debug.h Com_Util.c Com_Util.h app_data.c app_data.h Com_CRC.c Com_CRC.h
software components: CMSIS:CORE 4.3.0
